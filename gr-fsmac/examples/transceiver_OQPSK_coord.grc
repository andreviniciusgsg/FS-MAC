<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transceiver_coord</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>IEEE 802.15.4 Transceiver using OQPSK PHY</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2480000000</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>freq</value></param>
<param><key>choices</key><value>[1000000 * (2400 + 5 * (i - 10)) for i in range(11, 37)]</value></param>
<param><key>value</key><value>2520000000</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>labels</key><value>[i for i in range(11, 37)]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>gain</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>60</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>gain</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>20</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("12345678901234567890123456789012345678901234567890123456789012345678901234567890123456789012345678901234567890")</value></param>
<param><key>period</key><value>5e3</value></param>
</block>
<block>
<key>blocks_pdu_remove</key>
<param><key>id</key><value>blocks_pdu_remove_0</value></param>
<param><key>k</key><value>pmt.intern("es::event_buffer")</value></param>
</block>
<block>
<key>blocks_socket_pdu</key>
<param><key>id</key><value>blocks_socket_pdu_0_0</value></param>
<param><key>host</key><value></value></param>
<param><key>mtu</key><value>10000</value></param>
<param><key>port</key><value>52001</value></param>
<param><key>tcp_no_delay</key><value>False</value></param>
<param><key>type</key><value>"UDP_SERVER"</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_items</key><value>1024</value></param>
</block>
<block>
<key>es_handler_pdu</key>
<param><key>id</key><value>es_handler_pdu_0</value></param>
<param><key>dt</key><value>es.es_handler_print.TYPE_C32</value></param>
</block>
<block>
<key>es_sink</key>
<param><key>id</key><value>es_sink_0</value></param>
<param><key>eb</key><value>discard</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>nthreads</key><value>8</value></param>
<param><key>num_streams</key><value>1</value></param>
<param><key>ss</key><value>binary</value></param>
<param><key>samplehistory</key><value>64</value></param>
<param><key>cb</key><value>drop</value></param>
</block>
<block>
<key>es_trigger_sample_timer</key>
<param><key>id</key><value>es_trigger_sample_timer_0</value></param>
<param><key>length</key><value>512</value></param>
<param><key>period</key><value>int(1000)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>2</value></param>
<param><key>sched_dist</key><value>int(4000000)</value></param>
</block>
<block>
<key>fsmac_csma</key>
<param><key>id</key><value>fsmac_csma_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_node</key><value>1</value></param>
<param><key>mac_addr</key><value>0</value></param>
</block>
<block>
<key>fsmac_exchanger</key>
<param><key>id</key><value>fsmac_exchanger_0</value></param>
<param><key>is_coord</key><value>True</value></param>
</block>
<block>
<key>fsmac_latency_sensor</key>
<param><key>id</key><value>fsmac_latency_sensor_0</value></param>
<param><key>is_coord</key><value>True</value></param>
</block>
<block>
<key>fsmac_metrics_sensor</key>
<param><key>id</key><value>fsmac_metrics_sensor_0</value></param>
<param><key>is_coord</key><value>True</value></param>
<param><key>periodicity</key><value>5</value></param>
</block>
<block>
<key>fsmac_ml_decision</key>
<param><key>id</key><value>fsmac_ml_decision_0</value></param>
<param><key>aggr_max</key><value>1</value></param>
<param><key>aggr1</key><value>3</value></param>
<param><key>aggr2</key><value>1</value></param>
<param><key>aggr3</key><value>3</value></param>
<param><key>aggr4</key><value>4</value></param>
<param><key>aggr5</key><value>0</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>filename</key><value>/home/gnuradio/out_file.txt</value></param>
<param><key>ml_model</key><value>2</value></param>
<param><key>periodicity</key><value>30</value></param>
<param><key>training_file</key><value>/home/gnuradio/temp/training_file.txt</value></param>
<param><key>is_coord</key><value>True</value></param>
</block>
<block>
<key>fsmac_ml_decision</key>
<param><key>id</key><value>fsmac_ml_decision_1</value></param>
<param><key>aggr_max</key><value>1</value></param>
<param><key>aggr1</key><value>3</value></param>
<param><key>aggr2</key><value>1</value></param>
<param><key>aggr3</key><value>3</value></param>
<param><key>aggr4</key><value>4</value></param>
<param><key>aggr5</key><value>0</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>filename</key><value></value></param>
<param><key>ml_model</key><value>2</value></param>
<param><key>periodicity</key><value>20</value></param>
<param><key>training_file</key><value></value></param>
<param><key>is_coord</key><value>False</value></param>
</block>
<block>
<key>fsmac_sens_num_senders</key>
<param><key>id</key><value>fsmac_sens_num_senders_0</value></param>
</block>
<block>
<key>fsmac_snr</key>
<param><key>id</key><value>fsmac_snr_0</value></param>
<param><key>periodicity</key><value>2</value></param>
<param><key>threshold</key><value>-70</value></param>
<param><key>window_size</key><value>1024</value></param>
</block>
<block>
<key>fsmac_tdma</key>
<param><key>id</key><value>fsmac_tdma_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>dest_node</key><value>1</value></param>
<param><key>mac_addr</key><value>0</value></param>
<param><key>is_coord</key><value>True</value></param>
</block>
<block>
<key>ieee802_15_4_oqpsk_phy</key>
<param><key>id</key><value>ieee802_15_4_oqpsk_phy_0</value></param>
</block>
<block>
<key>ieee802_15_4_rime_stack</key>
<param><key>id</key><value>ieee802_15_4_rime_stack_0</value></param>
<param><key>bc_channels</key><value>[129]</value></param>
<param><key>rime_add</key><value>[23,42]</value></param>
<param><key>ruc_channels</key><value>[132]</value></param>
<param><key>uc_channels</key><value>[131]</value></param>
</block>
<block>
<key>logpwrfft_x</key>
<param><key>id</key><value>logpwrfft_x_0</value></param>
<param><key>avg_alpha</key><value>0.01</value></param>
<param><key>average</key><value>False</value></param>
<param><key>fft_size</key><value>1024</value></param>
<param><key>frame_rate</key><value>30</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ref_scale</key><value>2</value></param>
<param><key>sample_rate</key><value>4e6</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>you can connect to the Socket PDU with: 'nc -u localhost 52002'</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4000000</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhdgps_cpdu_average_power</key>
<param><key>id</key><value>uhdgps_cpdu_average_power_0</value></param>
<param><key>k</key><value>-60</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>strobe</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_pdu_remove_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>pdus</source_key><sink_key>cs in</sink_key></connection>
<connection><source_block_id>blocks_socket_pdu_0_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>pdus</source_key><sink_key>bcin</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>fsmac_snr_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_handler_pdu_0</source_block_id><sink_block_id>uhdgps_cpdu_average_power_0</sink_block_id><source_key>pdus_out</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_handler_pdu_0</sink_block_id><source_key>sample_timer_event</source_key><sink_key>handle_event</sink_key></connection>
<connection><source_block_id>es_trigger_sample_timer_0</source_block_id><sink_block_id>es_sink_0</sink_block_id><source_key>which_stream</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>fsmac_csma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>app out</source_key><sink_key>p1_app in</sink_key></connection>
<connection><source_block_id>fsmac_csma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>ctrl out</source_key><sink_key>p1_ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_csma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>pdu out</source_key><sink_key>p1_mac in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>ieee802_15_4_rime_stack_0</sink_block_id><source_key>app out</source_key><sink_key>fromMAC</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>dec out</source_key><sink_key>act protocol in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>mac out</source_key><sink_key>txin</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>p1_app out</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>p1_ctrl out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>p1_mac out</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_tdma_0</sink_block_id><source_key>p2_app out</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_tdma_0</sink_block_id><source_key>p2_ctrl out</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_exchanger_0</source_block_id><sink_block_id>fsmac_tdma_0</sink_block_id><source_key>p2_mac out</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>fsmac_latency_sensor_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>dec out</source_key><sink_key>sensor 2 in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>data frame out</source_key><sink_key>mac in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>rnp out</source_key><sink_key>sensor 3 in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>send request</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_tdma_0</sink_block_id><source_key>send request</source_key><sink_key>ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>snr out</source_key><sink_key>sensor 4 in</sink_key></connection>
<connection><source_block_id>fsmac_metrics_sensor_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>thr out</source_key><sink_key>max in</sink_key></connection>
<connection><source_block_id>fsmac_ml_decision_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>out</source_key><sink_key>dec in</sink_key></connection>
<connection><source_block_id>fsmac_sens_num_senders_0</source_block_id><sink_block_id>fsmac_ml_decision_0</sink_block_id><source_key>dec out</source_key><sink_key>sensor 1 in</sink_key></connection>
<connection><source_block_id>fsmac_snr_0</source_block_id><sink_block_id>fsmac_csma_0</sink_block_id><source_key>snr out</source_key><sink_key>snr in</sink_key></connection>
<connection><source_block_id>fsmac_snr_0</source_block_id><sink_block_id>fsmac_tdma_0</sink_block_id><source_key>snr out</source_key><sink_key>snr in</sink_key></connection>
<connection><source_block_id>fsmac_tdma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>app out</source_key><sink_key>p2_app in</sink_key></connection>
<connection><source_block_id>fsmac_tdma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>ctrl out</source_key><sink_key>p2_ctrl in</sink_key></connection>
<connection><source_block_id>fsmac_tdma_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>pdu out</source_key><sink_key>p2_mac in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>fsmac_latency_sensor_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>fsmac_metrics_sensor_0</sink_block_id><source_key>rxout</source_key><sink_key>frame in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>fsmac_sens_num_senders_0</sink_block_id><source_key>rxout</source_key><sink_key>pdu in</sink_key></connection>
<connection><source_block_id>ieee802_15_4_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>blocks_socket_pdu_0_0</sink_block_id><source_key>bcout</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>ieee802_15_4_rime_stack_0</source_block_id><sink_block_id>fsmac_exchanger_0</sink_block_id><source_key>toMAC</source_key><sink_key>app in</sink_key></connection>
<connection><source_block_id>logpwrfft_x_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>es_trigger_sample_timer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>ieee802_15_4_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>logpwrfft_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhdgps_cpdu_average_power_0</source_block_id><sink_block_id>blocks_pdu_remove_0</sink_block_id><source_key>cpdus</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>
